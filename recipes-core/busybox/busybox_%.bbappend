FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = "file://enable_i2ctools.cfg"